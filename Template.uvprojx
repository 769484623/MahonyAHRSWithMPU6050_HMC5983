# Keil uVision project Template.uvprojx, settings and files
target TJ (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\USR;.\LIB\inc;.\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USR
    ./USR/: main.c stm32f0xx_it.c system_stm32f0xx.c BSP.c I2C_Libary.c
  group LIB
    ./LIB/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_dma.c stm32f0xx_i2c.c stm32f0xx_spi.c stm32f0xx_tim.c
  group CORE
    ./CORE/: startup_stm32f0xx.s
  group Peri
    ./USR/: 5110.c MSE5611.c MPU6050.c HMC5983.c MahonyAHRS.c
